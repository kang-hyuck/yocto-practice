# IMAGE_INSTALL += "nano"
