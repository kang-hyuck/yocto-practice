IMAGE_INSTALL += "packagegroup-kh"
