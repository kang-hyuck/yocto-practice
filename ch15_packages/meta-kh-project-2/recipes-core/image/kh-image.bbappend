IMAGE_INSTALL += "packagegroup-kh"
IMAGE_INSTALL += "kh-lib"
IMAGE_INSTALL += "kh-uselib"
