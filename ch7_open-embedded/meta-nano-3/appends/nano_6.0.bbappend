#inherit rm_work

inherit externalsrc
EXTERNALSRC = "${COREBASE}/external-source/nano"
