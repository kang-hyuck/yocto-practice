inherit externalsrc
EXTERNALSRC = "${COREBASE}/external-source/kernel-source"
