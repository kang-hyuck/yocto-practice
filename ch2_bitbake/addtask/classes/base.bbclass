addtask test after do_build before do_install
